Commit message: Add files via upload

File: urdf/agv.urdf (robot description, URDF)
Before this commit: robot AGV-OTA, 13 links, 12 joints
Joints:
- joint scan_joint: origin xyz=0.35 0.0 0.15 rpy=0 0 3.14 -> xyz=0.35 0.0 0.15 rpy=0 0 0
